<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>am_receiver</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>AM Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>convert</value></param>
<param><key>value</key><value>125e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimate</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>770</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,12,1,10</value></param>
<param><key>label</key><value>Frequency in kHz</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>passband</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>6</value></param>
<param><key>grid_pos</key><value>0,4,1,3</value></param>
<param><key>label</key><value>Filter kHz</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>3</value></param>
<param><key>num_steps</key><value>7</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>10</value></param>
<param><key>grid_pos</key><value>0,1,1,3</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>max</key><value>70</value></param>
<param><key>min</key><value>10</value></param>
<param><key>num_steps</key><value>12</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vol</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>0,8,1,3</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>10000</value></param>
<param><key>audio_stop</key><value>11000</value></param>
<param><key>chan_rate</key><value>samp_rate/decimate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>passband*1000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/decimate</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>51e6</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>40</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>rtl_tcp=192.168.1.41:1234</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>500e3</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
