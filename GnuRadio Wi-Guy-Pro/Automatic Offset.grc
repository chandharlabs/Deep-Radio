<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ObserveFFT</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amp_gain</value></param>
<param><key>value</key><value>30.5</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>62</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>5.42e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_M</value></param>
<param><key>value</key><value>5651</value></param>
<param><key>label</key><value>Frequency (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>4900</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>DSP Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50e6</value></param>
<param><key>step</key><value>512</value></param>
<param><key>stop</key><value>50e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e6/512</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>512</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>const</key><value>1.024e3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(1024)</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq+offset</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>"output1"</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>J1</value></param>
<param><key>bw0</key><value>36e6</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq,lo_offset)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>amp_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_number_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_size</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
