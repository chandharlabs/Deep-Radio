options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_interp
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_interp
    quad_rate: audio_rate * audio_interp
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: audio_rate
  states: {}
- name: freq
  id: variable_text_box
  parameters:
    converver: float_converter
    formatter: None
    label: Frequency
    value: 90e6
  states: {state: disabled}
- name: gain
  id: variable_slider
  parameters:
    converver: float_converter
    label: Gain
    max: '90'
    min: '0'
    num_steps: '90'
    style: wx.SL_HORIZONTAL
    value: '40'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: audio_rate * audio_interp
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl_tcp=192.168.1.41:1234
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '20'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: 250e3
    sync: sync
    type: fc32
  states: {state: disabled}
- name: samp_rate
  id: variable_text_box
  parameters:
    converver: float_converter
    formatter: None
    label: Sample Rate
    value: 250e3
  states: {state: disabled}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: 100.3e6
    gain: '40.0'
    samp_rate: 500e3
    type: fc32
  states: {}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '-30'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FFT Plot
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rtlsdr_source_0, '0', wxgui_fftsink2_0, '0']
- [soapy_limesdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
