options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: vol1
  id: variable_qtgui_range
  parameters:
    label: Sumo
    start: '0'
    step: '.1'
    stop: '1'
    value: '0'
  states: {}
- name: vol2
  id: variable_qtgui_range
  parameters:
    label: Microfono
    start: '0'
    step: '.1'
    stop: '1'
    value: '0'
  states: {}
- name: vol3
  id: variable_qtgui_range
  parameters:
    label: Jaime Ross
    start: '0'
    step: '.1'
    stop: '1'
    value: '0'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 480000/(2*3.14*17000)
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/chandharlabs/Desktop/test.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '24000'
    gain: '1'
    interp: '1'
    samp_rate: audio_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: 40e3
    freq0: 90e6
    gain0: '20'
    if_gain0: '20'
    sample_rate: '500000'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: audio_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: '480000'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '480000'
    interp: '500000'
    taps: ''
    type: ccc
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: 2e6
    center_freq: 660e6
    gain: '50.0'
    samp_rate: 500e3
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0_0, '0']
- [audio_source_0, '0', low_pass_filter_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [rational_resampler_xxx_0_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', soapy_limesdr_sink_0, '0']

metadata:
  file_format: 1
