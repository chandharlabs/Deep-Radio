options:
  parameters:
    author: Rohit
    category: Custom
    generate_options: qt_gui
    id: OFDM_function
    output_language: python
    title: 'Basic OFDM '
  states: {}

blocks:
- name: carriers
  id: variable
  parameters:
    comment: Carrier
    value: ([-20,-10,-2,4,10,20],)
  states: {}
- name: carriers_0
  id: variable
  parameters:
    comment: Carrier
    value: (list(range(-(int(fft_len/2) - 3), 0))+list(range(1, int((fft_len/2) -2))),)
  states: {}
- name: cyclic_prefix
  id: variable
  parameters:
    comment: Cyclic prefix length
    value: fft_len/4
  states: {}
- name: fft_len
  id: variable
  parameters:
    comment: Size of FFT
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    comment: Tag name for packet length
    value: '"packet_len"'
  states: {}
- name: p_carriers
  id: variable
  parameters:
    comment: Pilot carriers
    value: (list(range(-(int(fft_len/2 -1)),-(int(fft_len/2 -3))))+list(range(int(fft_len/2 -2),int(fft_len/2))),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: Length of packet
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample Rate
    value: '1500000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Packets
    type: byte
  states: {state: disabled}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    maxoutbuf: '8192'
    minoutbuf: '4096'
    samples_per_second: samp_rate/2
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: carriers
    packet_len_key: '"rx_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: p_carriers
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_len = 1, default_log = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PAPR Calculator',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              #arr[]
              self.fft_len = fft_len
              self.memory_log = default_log
              
          def work(self, input_items, output_items):
              arr = input_items[0][:]
              length = self.fft_len 
              i = 1  
              PAPR_LOG = 0
              if arr.size == 4096:
                  while i <= 4096/self.fft_len:
                      temp = arr[(i-1)*length : (i*length)]
                      PAPR_LOG =20 * (np.log10(np.max(np.abs(temp)) / np.sqrt(np.mean(np.abs(temp)**2))))
                      self.memory_log = PAPR_LOG
                      output_items[0][:] = PAPR_LOG
                      i = i + 1
                  arr = []    
              else:
                  output_items[0][:] = self.memory_log          
              return len(output_items[0])
    default_log: '0'
    fft_len: fft_len
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Receiver Side
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0,buffers=128,buflen=32768
    bb_gain0: '20'
    bw0: 1.5e6
    freq0: 500e6
    gain0: '6'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: PAPR
    name: PAPR
    type: float
    unit1: dB
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Scope Plot Output
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Receiver Output
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 700e6
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 1.5e6
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_1_0, '0', epy_block_0_1_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_uchar_to_float_0, '0']
- [epy_block_0_1_0, '0', qtgui_number_sink_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_float_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_1_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_float_0, '0']
- [rtlsdr_source_0, '0', blocks_throttle_1_0, '0']
- [rtlsdr_source_0, '0', digital_ofdm_rx_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
