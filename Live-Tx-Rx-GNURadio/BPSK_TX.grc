options:
  parameters:
    generate_options: qt_gui
    id: bpsk_tx
    output_language: python
    title: BPSK_TX
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '915000000'
    step: '1'
    stop: '915020000'
    value: '915014100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: selector
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: selector
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: symbols
  id: variable
  parameters:
    value: '[0.4, 0.8, 1.2, 1.6]'
  states: {state: disabled}
- name: symbols
  id: variable
  parameters:
    value: '[1,1j, -1, -1j]'
  states: {state: disabled}
- name: symbols
  id: variable
  parameters:
    comment: |-
      need diagonals to use
      Constellation Decoder
    value: '[-1, +1]'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX GAIN
    start: '10'
    step: '1'
    stop: '64'
    value: '60'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '4'
    minimum: '0'
    seed: '0'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: byte
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    maxoutbuf: '1000000'
    num_inputs: '1'
    num_outputs: '2'
    output_index: selector
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0,1,0,0,0,0,0,1,1,1,1,1,0,0,1]'
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: symbols
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport time\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Text to Bits (Byte Output)',\n            in_sig=None,\n            out_sig=[np.uint8]  # Output individual bits as 0 or 1\n        )\n\n        # Load file as bytes\n        with open(\"/home/chandharlabs/Downloads/HackrfONE_RTLSDR_demo-main(1)/HackrfONE_RTLSDR_demo-main/test.txt\", \"rb\") as f:\n            byte_data = np.frombuffer(f.read(), dtype=np.uint8)\n\n        # Convert to bit array (uint8): each element is 0 or 1\n        bit_array = np.unpackbits(byte_data)\n\n        # Optional: prepend 100 zeros\n        bit_array = np.concatenate((np.zeros(100, dtype=np.uint8), bit_array))\n\n        self.symbol_values = bit_array  # Bits: 0 or 1\n        self.index = 0\n        self.last_repeat_time = time.time()\n        self.repeat_delay = 0  # seconds\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n = len(out)\n        out_index = 0\n\n        while out_index < n:\n            # Delay between repeats\n            if self.index == 0:\n                current_time = time.time()\n                if current_time < self.last_repeat_time + self.repeat_delay:\n                    return out_index\n                self.last_repeat_time = current_time\n\n            out[out_index] = self.symbol_values[self.index]\n            self.index += 1\n            out_index += 1\n\n            if self.index >= len(self.symbol_values):\n                self.index = 0  # Loop again if needed\n\n        return out_index\n\n"
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '20'
    if_gain0: tx_gain
    sample_rate: samp_rate*8
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    marker1: '0'
    marker2: '0'
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    name: '"CONSTELLATION DECODED SIGNAL"'
    size: 1024*8
    srate: samp_rate
    type: float
    ymax: '4'
  states: {state: disabled}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: freq
    gain: tx_gain
    samp_rate: samp_rate*8
    type: fc32
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_repeat_0, '0', osmosdr_sink_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repeat_0, '0', soapy_limesdr_sink_0, '0']
- [blocks_repeat_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_repeat_0, '0']
- [blocks_vector_source_x_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_selector_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [epy_block_0, '0', digital_diff_encoder_bb_0, '0']

metadata:
  file_format: 1
