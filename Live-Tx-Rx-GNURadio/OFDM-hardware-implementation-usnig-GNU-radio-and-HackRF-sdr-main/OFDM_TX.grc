options:
  parameters:
    author: Rohit
    category: Custom
    generate_options: qt_gui
    id: OFDM_function
    output_language: python
    title: 'Basic OFDM '
  states: {}

blocks:
- name: carriers
  id: variable
  parameters:
    comment: Carrier
    value: ([-20,-10,-2,4,10,20],)
  states: {}
- name: carriers_0
  id: variable
  parameters:
    comment: Carrier
    value: (list(range(-(int(fft_len/2) - 3), 0))+list(range(1, int((fft_len/2) -2))),)
  states: {}
- name: cyclic_prefix
  id: variable
  parameters:
    comment: Cyclic prefix length
    value: fft_len/4
  states: {}
- name: fft_len
  id: variable
  parameters:
    comment: Size of FFT
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: Size of FFT
    value: 700e6
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    comment: Tag name for packet length
    value: '"packet_len"'
  states: {}
- name: p_carriers
  id: variable
  parameters:
    comment: Pilot carriers
    value: (list(range(-(int(fft_len/2 -1)),-(int(fft_len/2 -3))))+list(range(int(fft_len/2 -2),int(fft_len/2))),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: Length of packet
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample Rate
    value: '1500000'
  states: {}
- name: blocks_complex_to_float_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/chandharlabs/Downloads/HackrfONE_RTLSDR_demo-main(1)/HackrfONE_RTLSDR_demo-main/test (copy).txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    log: 'True'
    occupied_carriers: carriers
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: p_carriers
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: note_0
  id: note
  parameters:
    note: Transmitter Side
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0,buffers=128,buflen=32768
    bb_gain0: '100'
    bw0: '1500000'
    freq0: 300e6
    gain0: '100'
    if_gain0: '100'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum1
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Transmitter Input
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: freq
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_limesdr_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
