options:
  parameters:
    author: Lt Raam
    generate_options: qt_gui
    id: qpsk_rx
    output_language: python
    title: QPSK RECEIVER
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    comment: |-
      Must know that symbols are secretly and
      automatically normalized so that
      mean(abs(symbols))==1
    const_points: symbols
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0,1,2,3]'
    type: calcdist
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-20e3'
    step: '1'
    stop: 20e3
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: selector
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: selector
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: symbols
  id: variable
  parameters:
    value: '[0.4, 0.8, 1.2, 1.6]'
  states: {state: disabled}
- name: symbols
  id: variable
  parameters:
    value: '[1,1j, -1, -1j]'
  states: {state: disabled}
- name: symbols
  id: variable
  parameters:
    comment: |-
      need diagonals to use
      Constellation Decoder
    value: '[-1-1j, -1+1j, 1+1j, 1-1j]'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_exponentiate_const_cci_0
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '4'
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Loop Bandwidth:
      2*3.14/100
    order: '4'
    w: 2*3.14/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '64'
    init_phase: '16'
    loop_bw: '0.02'
    max_dev: '1.5'
    osps: '1'
    sps: '15'
    taps: firdes.root_raised_cosine(32, 32, 1.0, 0.35, 11*32)
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport os\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Burst Capture with Downsampling and ASCII Decode',\n            in_sig=[np.uint8],\n            out_sig=None\n        )\n\n        self.zero_count = 0\n        self.zero_threshold = 1000\n        self.capturing = False\n        self.buffer = []\n\n        # Output files\n        self.raw_file = open(\"peak_capture_clean.txt\", \"w\")\n        self.ascii_file = open(\"decoded_ascii.txt\", \"w\")\n\n        # Accumulated bitstream\n        self.rx_bits = []\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n\n        for val in in0:\n            if val == 0:\n                self.zero_count += 1\n                if self.capturing:\n                    self.buffer.append(val)\n            else:\n                if not self.capturing and self.zero_count >= self.zero_threshold:\n                    self.capturing = True\n                    self.buffer = [val]\n                elif self.capturing:\n                    self.buffer.append(val)\n                self.zero_count = 0\n\n            if self.capturing and self.zero_count >= self.zero_threshold:\n                self._save_and_decode()\n                self.buffer = []\n                self.capturing = False\n\n        return len(in0)\n\n    def _trim_zeros(self, buf):\n        arr = np.array(buf)\n        nonzero = np.nonzero(arr)[0]\n        if nonzero.size == 0:\n            return []\n        start, end = nonzero[0], nonzero[-1] + 1\n        return arr[start:end].tolist()\n\n    def _burst_downsample_from_peak(self, values, zero_gap_threshold=120):\n        result = []\n        last_index = None\n        i = 0\n        n = len(values)\n\n        while i < n:\n            if values[i] != 0:\n                start = i\n                sym = values[i]\n                while i < n and values[i] == sym:\n                    i += 1\n                if last_index is not None and (start - last_index) > zero_gap_threshold:\n                    result.append(0)\n                result.append(sym)\n                last_index = start\n            else:\n                i += 1\n\n        return result\n\n    def _save_and_decode(self):\n        trimmed = self._trim_zeros(self.buffer)\n        if not trimmed:\n            return\n\n        downsampled = self._burst_downsample_from_peak(trimmed)\n        if not downsampled:\n            return\n\n        self.raw_file.write(\" \".join(map(str, downsampled)) + \"\\n\")\n        self.raw_file.flush()\n\n        bits = self._symbols_to_bits(downsampled)\n        if not bits:\n            return\n\n        # Convert bits to ASCII and write\n        ascii_str = self._decode_bits_to_ascii(bits)\n        self.ascii_file.write(ascii_str + \"\\n\")\n        self.ascii_file.flush()\n\n        # ✅ Extract bits from decoded ASCII (not from symbols)\n        decoded_bytes = ascii_str.encode('utf-8', errors='replace')\n        binary_bits = np.unpackbits(np.frombuffer(decoded_bytes, dtype=np.uint8))\n\n        # ✅ Save binary_bits as rx_bits\n        np.save(\"rx_bits.npy\", binary_bits)\n        with open(\"rx_bits.txt\", \"w\") as f:\n            np.savetxt(f, binary_bits, fmt='%d', delimiter='')\n\n       \n        # ✅ Compute BER if tx_bits.npy exists\n        if os.path.exists(\"tx_bits.npy\"):\n            tx_bits = np.load(\"tx_bits.npy\")\n            min_len = min(len(tx_bits), len(binary_bits))\n            bit_errors = np.sum(tx_bits[:min_len] != binary_bits[:min_len])\n            ber = bit_errors / min_len\n            with open(\"ber_result.txt\", \"a\") as f:\n                f.write(f\"Bit Errors: {bit_errors}\\n\")\n                f.write(f\"Total Bits Compared: {min_len}\\n\")\n                f.write(f\"BER: {ber:.8f}\\n\")\n        else:\n            with open(\"ber_result.txt\", \"a\") as f:\n                f.write(\"tx_bits.npy not found. BER not computed.\\n\")\n\n        # Check if the CSV file already exists\n        write_header = not os.path.exists(\"ber_log.csv\")\n\n         # Append the new BER entry\n        with open(\"ber_log.csv\", \"a\") as csv_file:\n            if write_header:\n                csv_file.write(\"Total Bits Compared,Bit Errors,BER\\n\")\n            csv_file.write(f\"{min_len},{bit_errors},{ber:.8f}\\n\")\n\n\n\n    def _symbols_to_bits(self, symbols):\n        bits = []\n        for sym in symbols:\n            bits.extend([(sym >> 1) & 1, sym & 1])  # MSB first\n        return bits\n\n    def _decode_bits_to_ascii(self, bits):\n        padded_bits = bits.copy()\n        while len(padded_bits) % 8 != 0:\n            padded_bits.append(0)\n\n        bytes_out = []\n        for i in range(0, len(padded_bits), 8):\n            byte_val = 0\n            for b in padded_bits[i:i+8]:\n                byte_val = (byte_val << 1) | b\n            bytes_out.append(byte_val)\n\n        try:\n            return bytes(bytes_out).decode('utf-8', errors='replace')\n        except Exception as e:\n            return f\"[Decode Error: {e}]\"\n\n    def _finalize_rx_data(self):\n        if not self.rx_bits:\n            with open(\"ber_result.txt\", \"w\") as f:\n                f.write(\"No received bits detected. BER not computed.\\n\")\n            return\n\n        rx_bits_array = np.array(self.rx_bits, dtype=np.uint8)\n        np.save(\"rx_bits.npy\", rx_bits_array)\n        np.savetxt(\"rx_bits.txt\", rx_bits_array, fmt='%d')\n\n        if os.path.exists(\"tx_bits.npy\"):\n            tx_bits = np.load(\"tx_bits.npy\")\n            min_len = min(len(tx_bits), len(rx_bits_array))\n            tx_trim = tx_bits[:min_len]\n            rx_trim = rx_bits_array[:min_len]\n            bit_errors = np.sum(tx_trim != rx_trim)\n            ber = bit_errors / min_len\n            with open(\"ber_result.txt\", \"w\") as f:\n                f.write(f\"Bit Errors: {bit_errors}\\n\")\n                f.write(f\"Total Bits Compared: {min_len}\\n\")\n                f.write(f\"BER: {ber:.8f}\\n\")\n        else:\n            with open(\"ber_result.txt\", \"w\") as f:\n                f.write(\"tx_bits.npy not found. BER not computed.\\n\")\n\n    def __del__(self):\n        # Final capture check\n        if self.capturing and self.buffer:\n            self._save_and_decode()\n\n        self._finalize_rx_data()\n        self.raw_file.close()\n        self.ascii_file.close()\n\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self, threshold=0.3):\n        gr.sync_block.__init__(\n            self,\n            name='AmplitudeGate',\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        self.threshold = threshold\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n\n        avg_amplitude = np.mean(np.abs(in0))\n\n        if avg_amplitude > self.threshold:\n            out[:] = in0\n        else:\n            out[:] = np.zeros_like(in0)\n\n        return len(out)\n\n"
    threshold: '.1'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*4
    type: fir_filter_ccf
    width: samp_rate
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*4
    type: fir_filter_ccf
    width: samp_rate
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: Receive Raw
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: Receive Tuned
    name: '"RECEIVED CONSTELLATION SINK WITH SIGNAL SOURCE"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: Receive Costas
    name: '"RECEIVED CONSTELLATION SINK WITH SIGNAL SOURCE AFTER COSTAS LOO"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    label1: Receive Raw
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    label1: Receive Tuned
    name: '"RECEIVED FREQUENCY SINK WITH SIGNAL SOURCE"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Receive Raw Re
    label2: Receive Raw Im
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Receive Tuned Re
    label2: Receive Tuned Im
    name: '"RECEIVED TIME SINK WITH SIGNAL SOURCE"'
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Receive^4 Re
    label2: Receive^4 Im
    name: '"RECEIVED AFTER AGC"'
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: Receive Costas Re
    label2: Receive Costas Im
    name: '"RECEIVED TIME SINK WITH SIGNAL SOURCE AFTER COSTAS LOOP"'
    size: 1024*8*20
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    name: '"CONSTELLATION DECODED SIGNAL"'
    size: 1024*8
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_exponentiate_const_cci_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_exponentiate_const_cci_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_multiply_xx_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_repeat_0, '0', epy_block_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', low_pass_filter_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_repeat_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', low_pass_filter_0_0, '0']
- [epy_block_1, '0', digital_constellation_decoder_cb_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [low_pass_filter_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [low_pass_filter_0_0, '0', epy_block_1, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', qtgui_const_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
