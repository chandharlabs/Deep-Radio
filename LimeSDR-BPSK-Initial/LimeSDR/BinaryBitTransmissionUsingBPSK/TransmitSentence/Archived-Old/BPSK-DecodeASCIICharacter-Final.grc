options:
  parameters:
    generate_options: qt_gui
    id: tempBpskDecoding
    output_language: python
    title: BPSK Decoder
  states: {}

blocks:
- name: bb_gain_slider
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '15'
  states: {}
- name: if_gain_slider
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rf_gain_slider
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: selector
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: selector
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: int
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_int_1
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    maxoutbuf: '1000000'
    num_inputs: '1'
    num_outputs: '2'
    output_index: selector
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: '5'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: int
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    use_snr: 'True'
    w: '.02'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '64'
    init_phase: '16'
    loop_bw: '0.02'
    max_dev: '1.5'
    osps: '1'
    sps: '15'
    taps: firdes.root_raised_cosine(32, 32, 1.0, 0.35, 11*32)
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass BitSaver(gr.sync_block):\n    def __init__(self, filename=\"bits.txt\"):\n        \"\"\"\n        Saves extracted bit sequences (0s and 1s) to a text file.\n        :param filename: Name of the file to save bits.\n        \"\"\"\n        gr.sync_block.__init__(self,\n                               name=\"Bit Saver\",\n                               in_sig=[np.uint8],  # Input: Bitstream (0s and 1s)\n                               out_sig=None)  # No output, just save\n\n        self.filename = filename\n\n    def work(self, input_items, output_items):\n        in_data = input_items[0]  # Input bit sequence (array of 0s and 1s)\n\n        # Convert bits to string format\n        bit_string = ''.join(map(str, in_data.tolist()))\n\n        # Save to a text file\n        with open(self.filename, \"a\") as f:  # Append mode\n            f.write(bit_string + \"\\n\")\n\n        return len(in_data)\n\n"
    filename: '"bitsave.txt"'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from collections import Counter
      from gnuradio import gr
      import threading

      class bpsk_decoder(gr.sync_block):
          def __init__(self, transmittedBitsLen=11, transition_threshold=0.5, bit_validation_threshold=0.7, silence_threshold=20000, bit_length=1300, buffer_size=500000,  starting_sequence="0,1,0"):
              gr.sync_block.__init__(self,
                  name="BPSK Decoder",
                  in_sig=[np.complex64],
                  out_sig=None)
              
              self.transmittedBitsLen = transmittedBitsLen
              self.transition_threshold = transition_threshold
              self.bit_validation_threshold = bit_validation_threshold
              self.silence_threshold = silence_threshold
              self.bit_length = bit_length
              self.starting_sequence = list(map(int, starting_sequence.split(',')))
              
              self.buffer_size = buffer_size  # Half a million samples
              self.data_buffer = np.array([], dtype=np.complex64)
              self.bit_sequences = []
              self.lock = threading.Lock()

          def process_data(self, data):
              real_part = np.real(data)
              
              # Find all transition indices where signal crosses ±0.5
              transition_indices = np.where((real_part[:-1] < self.transition_threshold) & (real_part[1:] > self.transition_threshold) |
                                            (real_part[:-1] > -self.transition_threshold) & (real_part[1:] < -self.transition_threshold))[0]
              
              if len(transition_indices) == 0:
                  return

              start_index = transition_indices[0]

              while start_index < len(real_part):
                  segment = real_part[start_index:start_index + (self.transmittedBitsLen + 1) * 1300]
                  arr_processed = np.where(segment > self.transition_threshold, 1, np.where(segment < -self.transition_threshold, 0, segment))
                  
                  if np.mean(arr_processed[:self.silence_threshold]) < 0.1:
                      next_transition = transition_indices[transition_indices > start_index + self.silence_threshold]
                      if len(next_transition) == 0:
                          break
                      start_index = next_transition[0]
                      continue

                  bits = []
                  i = 0
                  while i < len(arr_processed) - self.bit_length:
                      bit_segment = arr_processed[i:i + self.bit_length]
                      avg_value = np.mean(bit_segment)
                      if avg_value > self.bit_validation_threshold:
                          bits.append(1)
                      elif avg_value < (1 - self.bit_validation_threshold):
                          bits.append(0)
                      else:
                          i += self.bit_length
                          continue
                      i += self.bit_length

                  # Extract the starting sequence and the actual message bits
                  if bits[:len(self.starting_sequence)] == self.starting_sequence:
                      actual_bits = bits[len(self.starting_sequence):]
                      self.bit_sequences.append(tuple(actual_bits))

                  next_transition = transition_indices[transition_indices > start_index + len(segment)]
                  if len(next_transition) == 0:
                      break
                  start_index = next_transition[0]

              if len(self.bit_sequences) > 0:
                  message = ""
                  for bit_sequence in self.bit_sequences:
                      # Split the bit sequence into 8-bit chunks and convert to characters
                      for i in range(0, len(bit_sequence), 8):
                          byte = bit_sequence[i:i+8]
                          if len(byte) == 8:
                              ascii_char = chr(int(''.join(map(str, byte)), 2))
                              message += ascii_char
                  
                  with open("decoded_message.txt", "a") as file:
                      file.write(f"{message}\n")

                  self.bit_sequences = []

          def work(self, input_items, output_items):
              with self.lock:
                  self.data_buffer = np.concatenate((self.data_buffer, input_items[0]))

              if len(self.data_buffer) >= self.buffer_size:
                  data_to_process = self.data_buffer[:self.buffer_size]
                  self.data_buffer = self.data_buffer[self.buffer_size:]
                  
                  threading.Thread(target=self.process_data, args=(data_to_process,)).start()

              return len(input_items[0])
    bit_length: '1300'
    bit_validation_threshold: '0.7'
    buffer_size: '1000000'
    silence_threshold: '20000'
    starting_sequence: '''0,1,0'''
    transition_threshold: threshold
    transmittedBitsLen: '13'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass BitExtractor(gr.sync_block):\n    def __init__(self, samples_per_bit=10000, bit_count=10, threshold=0.5):\n        gr.sync_block.__init__(self,\n                               name=\"Bit Extractor\",\n                               in_sig=[np.float32],   # Input: Float samples from Threshold Block\n                               out_sig=[np.uint8])    # Output: Binary bits (0 or 1)\n\n        self.samples_per_bit = samples_per_bit\n        self.bit_count = bit_count\n        self.threshold = threshold\n        self.started = False  # Flag to detect first peak\n        self.count = 0        # Track extracted samples\n        self.buffer = []      # Store extracted samples\n\n    def work(self, input_items, output_items):\n        in_data = input_items[0]\n        out_data = output_items[0]\n        print(\"Indata length : \", len(in_data))\n\n        # If first peak not detected, look for it\n        if not self.started:\n            first_peak_idx = np.argmax(in_data > self.threshold)  # Find first 1\n            # print(\"Peak index : \", first_peak_idx)\n            if first_peak_idx == 0 and in_data[0] <= self.threshold:\n                return 0  # No peak found, wait for more samples\n\n            # Start capturing after peak\n            self.started = True\n            self.count = 0\n            in_data = in_data[first_peak_idx:]  # Trim data to start from peak\n\n        # Collect up to 100,000 samples\n        remaining = self.bit_count * self.samples_per_bit - self.count\n        to_copy = min(len(in_data), remaining)\n        self.buffer.extend(in_data[:to_copy])\n        self.count += to_copy\n\n        # If 100,000 samples are collected, extract bits\n        if self.count >= self.bit_count * self.samples_per_bit:\n            bitstream = np.array(self.buffer)[::self.samples_per_bit]  # Downsample\n            bitstream = (bitstream > self.threshold).astype(np.uint8)  # Convert to binary\n            \n            out_data[:len(bitstream)] = bitstream\n            self.started = False  # Reset for next detection\n            self.buffer = []       # Clear buffer\n            self.count = 0\n            return len(bitstream)\n\n        return 0  # Wait for more samples\n\n"
    bit_count: '10'
    samples_per_bit: '10000'
    threshold: '0.5'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 500e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 300e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '102400'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '102400'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.3'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    size: '202400'
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-0.3'
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '202400'
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-0.3'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: bb_gain_slider
    freq0: 700e6
    gain0: rf_gain_slider
    gain_mode0: 'False'
    if_gain0: if_gain_slider
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_xor_xx_0, '1']
- [blocks_float_to_char_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_float_to_int_0, '0', blocks_delay_0, '0']
- [blocks_float_to_int_1, '0', blocks_xor_xx_0, '0']
- [blocks_int_to_float_0, '0', blocks_float_to_char_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_1_1_0, '0']
- [blocks_selector_0, '1', epy_block_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_tagged_stream_to_pdu_1, pdus, blocks_message_debug_0, print_pdu]
- [blocks_xor_xx_0, '0', blocks_int_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_selector_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_1_1, '0']
- [epy_block_2, '0', blocks_char_to_float_0, '0']
- [low_pass_filter_0, '0', digital_costas_loop_cc_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
