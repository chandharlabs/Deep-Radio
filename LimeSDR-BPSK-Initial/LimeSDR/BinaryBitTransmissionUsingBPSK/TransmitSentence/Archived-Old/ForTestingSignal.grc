options:
  parameters:
    generate_options: qt_gui
    id: tempBpskDecoding
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bb_gain_slider
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '15'
  states: {}
- name: if_gain_slider
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rf_gain_slider
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: int
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_int_1
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: '5'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: int
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    use_snr: 'True'
    w: '.02'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '64'
    init_phase: '16'
    loop_bw: '0.02'
    max_dev: '1.5'
    osps: '1'
    sps: '15'
    taps: firdes.root_raised_cosine(32, 32, 1.0, 0.35, 11*32)
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
          """Embedded Python Block for Bitstream Decoding"""

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Bitstream Decoder',  
                  in_sig=[np.float32],  # Accepting float input from Threshold block
                  out_sig=[]  # No direct output, just processing
              )

              # Patterns for start and stop detection
              self.start_pattern = [1, 0, 0, 0, 1]
              self.stop_pattern = [1, 1, 1, 1]
              self.collecting = False  # Flag to track message extraction
              self.message_bits = []  # Stores message bits
              self.buffer = []  # Temporary buffer for incoming bits
              self.maxDisplay = 0

          def work(self, input_items, output_items):
              in_data = input_items[0]  # Input from Threshold block (float values)

              # Convert float values to binary (Thresholding)
              binary_data = [1 if x > 0 else 0 for x in in_data]

              for bit in binary_data:
                  self.buffer.append(bit)
                  # print("Bits : ", bit)

                  if maxDisplay < 10000:
                      print("Bits : ", bit)
                      self.maxDisplay = +1

                  # Limit buffer size to prevent memory issues
                  if len(self.buffer) > 10000:
                      self.buffer.pop(0)

                  # Check for start pattern
                  if not self.collecting and self.buffer[-5:] == self.start_pattern:
                      self.collecting = True
                      self.message_bits = []  # Reset message buffer
                      continue  

                  # Collect message bits
                  if self.collecting:
                      self.message_bits.append(bit)

                      # Check for stop pattern
                      if len(self.message_bits) >= 5 and self.message_bits[-5:] == self.stop_pattern:
                          # Remove stop pattern from message
                          self.message_bits = self.message_bits[:-5]

                          # Decode and print/save message
                          decoded_message = self.decode_message(self.message_bits)
                          print(f"Decoded Message: {decoded_message}")

                          # Save to file
                          with open("decoded_message.txt", "a") as file:
                              file.write(decoded_message + "\n")

                          # Reset state
                          self.collecting = False
                          self.message_bits = []

              return len(input_items[0])  # Consume all input items

          def decode_message(self, bits):
              """Convert 4-bit chunks into a hex string."""
              hex_message = []
              for i in range(0, len(bits), 4):
                  chunk = bits[i:i+4]
                  if len(chunk) == 4:
                      hex_value = int("".join(map(str, chunk)), 2)
                      hex_message.append(format(hex_value, "X"))  
              return "".join(hex_message)
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass PhaseCorrector(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self, \n                               name=\"Phase Corrector\",\n                               in_sig=[np.complex64],\n                               out_sig=[np.complex64])\n        self.last_symbol = None\n\n    def work(self, input_items, output_items):\n        in_data = input_items[0]\n        out_data = output_items[0]\n\n        # Detect if phase has flipped\n        if self.last_symbol is not None:\n            phase_diff = np.angle(in_data[0] * np.conj(self.last_symbol))\n            if abs(phase_diff) > np.pi / 2:  # 180° phase flip\n                out_data[:] = -in_data  # Correct the flip\n            else:\n                out_data[:] = in_data\n        else:\n            out_data[:] = in_data\n\n        self.last_symbol = in_data[-1]  # Store last symbol for comparison\n        return len(out_data)\n\n"
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 500e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 300e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '202400'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '202400'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.3'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: bb_gain_slider
    freq0: 700e6
    gain0: rf_gain_slider
    gain_mode0: 'False'
    if_gain0: if_gain_slider
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_threshold_ff_0, '0']
- [blocks_delay_0, '0', blocks_xor_xx_0, '1']
- [blocks_float_to_char_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_float_to_int_0, '0', blocks_delay_0, '0']
- [blocks_float_to_int_1, '0', blocks_xor_xx_0, '0']
- [blocks_int_to_float_0, '0', blocks_float_to_char_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_tagged_stream_to_pdu_1, pdus, blocks_message_debug_0, print_pdu]
- [blocks_threshold_ff_0, '0', blocks_float_to_int_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_int_1, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_xor_xx_0, '0', blocks_int_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', epy_block_1_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_1_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', digital_costas_loop_cc_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
