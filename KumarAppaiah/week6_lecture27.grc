options:
  parameters:
    author: p
    generate_options: qt_gui
    id: week6_lecture27
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: myconst
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: noisestd
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '10'
    value: '0'
  states: {}
- name: r_imag
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.05'
    stop: '1'
    value: '1'
  states: {}
- name: r_real
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.05'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: r_real+ 1j* r_imag
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noisestd
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: myconst
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters: {}
  states: {}
- name: digital_constellation_encoder_bc_1
  id: digital_constellation_encoder_bc
  parameters: {}
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: TEST
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', digital_constellation_decoder_cb_0, '0']
- [analog_const_source_x_0, '0', qtgui_const_sink_x_1, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_constellation_encoder_bc_1, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_add_xx_0, '0']
- [digital_constellation_encoder_bc_1, '0', qtgui_const_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
